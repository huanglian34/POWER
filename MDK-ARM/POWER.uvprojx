# Keil uVision project POWER.uvprojx, settings and files
target POWER (6220000::V6.22::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: POWER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/Controller;../User/Controller/Loop;../User/Storager/Driver;../User/Storager/Param;../User/Storager/Storage;../User/Communicator/uf4com/protocol/Inc;../User/Communicator/uf4com/register/Inc;../User/Communicator/cherryusb/core;../User/Communicator/cherryusb/common;../User/Communicator/cherryusb/class/cdc;../User/Communicator/cherryusb/port/fsdev;../User/Communicator/uf4com/transport/uf4com_usb_cdc/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: power_ccm.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c dac.c dma.c fmac.c hrtim.c iwdg.c spi.c tim.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fmac.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group User/Controller
    ../User/Controller/: control_app.c power_mode.c protection_control.c pwm_control.c temperature_sensor.c
  group User/Controller/Loop
    ../User/Controller/Loop/: control_loop.c control_pid.c current_loop.c current_loop_schedule.c voltage_loop.c
  group User/Storager
    ../User/Storager/Driver/: Flash_Init.c W25QXX.c
    ../User/Storager/Param/: param_backend.c param_crc.c param_manager.c param_table.c param_uf4com.c param_validate.c
    ../User/Storager/Storage/: storage_ab.c storage_layout.c
  group User/Communicator
    ../User/Communicator/uf4com/protocol/Src/: uf4com.c uf4com_cmd.c uf4com_crc.c uf4com_parser.c
    ../User/Communicator/uf4com/register/Src/: uf4com_id_table.c
    ../User/Communicator/uf4com/transport/uf4com_usb_cdc/Src/: uf4com_usb_cdc.c
  group User/CherryUSB
    ../User/Communicator/cherryusb/core/: usbd_core.c
    ../User/Communicator/cherryusb/class/cdc/: usbd_cdc_acm.c
    ../User/Communicator/cherryusb/port/fsdev/: usb_dc_fsdev.c
software components: CMSIS:CORE 6.2.0
